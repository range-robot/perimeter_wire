# Repository range-robot/perimeter_wire

File Readme.md:

# Perimeter Wire

This repository contains the hardware and software for a perimeter wire sensor designed for autonomous navigation. The project was originally developed by Meadow Robotics and is now released under the GNU General Public License (GPL) following the discontinuation of Meadow Robotics.

This repository is not under active development. However commercial support is available. You can contact me at [@mistoll](https://github.com/mistoll).

The system comprises a generator and a sensor. The generator produces a software-defined signal and operates within a voltage range of 9 to 48V.
The sensor is equipped with three sensor coils for three axes, with the option to also mount Hall sensors. The sensor signal undergoes amplification and is then processed entirely in digital form.

The driver is built on ROS (Robot Operating System) but is also adaptable to other systems.

## License

This project is licensed under the GNU General Public License (GPL) - see the [LICENSE.md](LICENSE.md) file for details.

## Alternative products

 * https://www.goetting-agv.com/components/inductive
 * http://wiki.ardumower.de/index.php?title=Perimeter_wire
 * https://www.robotshop.com/de/de/robotshop-perimeter-wire-generator-sensor-soldering-kit.html

## Theory

Magnetic field strength for z coil:
k: konstant
x: distance orthogonal to wire
d: distance above ground (to wire)

B=k * x / (d^2 + x^2)
https://www.wolframalpha.com/input/?i=sin(arctan(x%2Fd))+*+cos(arctan(x%2Fd))%2Fd

We can use the difference of the absolute signal of two coild to get a 0-crossing signal
For d = 0.4 and coil distance 0.05 we get:
https://www.wolframalpha.com/input/?i=%7Csin%28arctan%28x%2F0.4%29%29+*+cos%28arctan%28x%2F0.4%29%29%2F0.4%7C+-+%7Csin%28arctan%28%28x-0.05%29%2F0.4%29%29+*+cos%28arctan%28%28x-0.05%29%2F0.4%29%29%2F0.4%7C

## Orientation

The hardware is designed to measure a vector in a cartesian coordinate system. However the coil for x is inverted.

Looking at the magnetic field of a loop. We define z > 0 to be inside the loop and when above the loop y > 0 to be forward direction. In that case x > 0 means rotation to the right.

When the pcb is mounted flat on the robot and upper pcb is facing in drive direction orientation is '-xyz'.  When it's upside down (in case) and facing in drive direction orientation is '-x-y-z'. And when its mounted on the front of the robot, with the case / pcb facing in drive direction orientation is '-z-yx'.

## Debugging

* Compile using --cmake-args -DCMAKE_BUILD_TYPE=Debug
* Run openocd
* Connect using vs code (native-debug)

```
"type": "gdb",
"request": "attach",
"name": "Attach to gdbserver",
"executable": "//home/michael/golfcart/workspace/devel/.private/perimeter_wire_generator_firmware/lib/perimeter_wire_generator_firmware/firmware-ATSAMD21E17D.elf",
"gdbpath": "gdb-multiarch",
"target": ":3333",
"remote": true,
"cwd": "${workspaceRoot}/firmware/generator",
"valuesFormatting": "parseText",
```

## Program and Test

See prod/Testing.md

## KiCad design pcb/generator/generator.kicad_pcb

Parts:
C1, C2: 100u / 100V; CP_Radial_D10.0mm_P5.00mm; Partnumber UVR1J101MPD
C3, C4, C5, C6, C7, C9, C19: 100n; C_0805_2012Metric; Partnumber CL21B104MBCNNNC
C8: 220n; C_0805_2012Metric; Partnumber CL21B224KCFSFNE
C10, C11, C12, C13: 220n / 100V; C_0805_2012Metric; Partnumber CL21B224KCFSFNE
C14, C15: 22p; C_0805_2012Metric; Partnumber C0805C220K5GACTU
C16, C17: 10n; C_0805_2012Metric; Partnumber CL21B103KBANNNC
C18: 47u; CP_EIA-6032-28_Kemet-C; Partnumber TAJC476K020R
D1: D; SOT-23; Partnumber MMBD7000LT1G
D3, D4: CLMVC-FKA; LED_Cree-PLCC4_2x2mm_CW; Partnumber CLMVC-FKA
D5: 5V; D_SMB; Partnumber SMBJ5.0ATR
D6, D7: BAT54; SOT-23; Partnumber BAT54HMFHT116
D8: 48V; D_SMB; Partnumber SMBJ48CATR
E1, E2, E3, E4, E5, E6, E7: SPARK_GAP; Spark_Gap_0.4_Pwr
FB1: BLM31KN471SN1L; L_1206_3216Metric; Partnumber BLM31KN471SN1L
FB2: BLM31SN500SN1L; L_1206_3216Metric; Partnumber BLM31SN500SN1
FID1, FID2, FID3, FID4, FID5, FID6: Fiducial; Fiducial_1mm_Mask2mm
J1: Power; TerminalBlock_bornier-2_P5.08mm; Partnumber VI0221520000G
J2: SWD; PinHeader_2x05_P1.27mm_Vertical_SMD; Partnumber 3221-10-0300-00
J3: CH1; TerminalBlock_bornier-3_P5.08mm; Partnumber VI0321550000G
J4: CH2; TerminalBlock_bornier-3_P5.08mm; Partnumber VI0321550000G
J5: USB; USB_Micro-B_Molex-105133-0001; Partnumber 1051330011
J6: Au; PinSocket_2x05_P2.54mm_Vertical; Partnumber BCS-105-F-D-TE
J7: Bu; PinSocket_2x05_P2.54mm_Vertical; Partnumber BCS-105-F-D-TE
J8: Al; PinHeader_2x05_P2.54mm_Vertical; Partnumber DW-05-14-T-D-1100
J9: Bl; PinHeader_2x05_P2.54mm_Vertical; Partnumber DW-05-14-T-D-1100
N1: Italtronic Modulbox XTS 3M; Partnumber 25.0302000.BL; P05030206T.BL; P05030203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
R1, R2, R3, R4, R5: 22k; R_0805_2012Metric; Partnumber RMCF0805FT22K0
R6, R7: 200R; Ohmite-TKH; Partnumber TKH45P200RFE-TR
R8: 1k; R_0805_2012Metric; Partnumber RMCF0805FT1K00
R9, R10: 1M; R_0805_2012Metric; Partnumber RMCF0805FT1M00
R11, R12: 280R; R_0805_2012Metric; Partnumber RMCF0805FT280R
R13, R14, R15, R16, R17: 100R; R_0805_2012Metric; Partnumber RMCF0805FT100R
U1: ATSAMD21E; TQFP-32_7x7mm_P0.8mm; Partnumber ATSAMD21E17D
U2: SRH05S3V3; Converter_DCDC_RECOM_R-78HB-0.5_THT; Partnumber SRH05S3V3
U3: L6206; PowerSO-36; Partnumber L6206PD
U4: MCP9700T-HLT; SOT-353_SC-70-5; Partnumber MCP9700T-H/LT
U5: LP2985-3.3; SOT-23-5; Partnumber LP2985-33DBVR
U6: SN65220; SOT-23-6; Partnumber SN65220DBVRG4‎
Y1: 16MHz; Crystal_SMD_SeikoEpson_TSX3225-4Pin_3.2x2.5mm; Partnumber TSX-3225 16.0000MF10U-B0

Connections:
+3V3: C3.2, C7.1, C9.1, C18.1, D3.1 (A), D4.1 (A), D6.1 (A), D6.2 (A), D7.1 (A), D7.2 (A), J2.1, J7.10, J9.10, R8.1, U1.9 (VDDANA), U1.30 (VDDIN), U2.3 (OUT), U4.4 (Vdd), U5.5 (VOUT)
+48V: C1.1, C2.1, C8.2, C10.2, C11.2, C12.2, C13.2, D1.1 (A), D7.3 (K), FB2.1, J7.8, J9.8, R9.1, U2.1 (IN), U3.4 (VS_A), U3.33 (VS_B)
/EN_A: R1.2, U1.11 (PA08)
/EN_B: R2.2, U1.1 (PA00)
/ERROR_A: C5.1, J6.9, J8.9, R1.1, U1.12 (PA09), U3.8 (EN_A), U3.13 (OCD_A)
/ERROR_B: C6.1, J7.9, J9.9, R2.1, U1.2 (PA01), U3.24 (OCD_B), U3.29 (EN_B)
/IN1_A: J6.5, J8.5, U1.7 (PA06), U3.10 (IN1_A)
/IN1_B: J7.5, J9.5, U1.3 (PA02), U3.26 (IN1_B)
/IN2_A: J6.3, J8.3, U1.8 (PA07), U3.11 (IN2_A)
/IN2_B: J7.3, J9.3, U1.4 (PA03), U3.27 (IN2_B)
/R_TEMP: J6.10, J8.10, U1.6 (PA05), U4.3 (Vout)
/SWCLK: J2.4, R8.2, U1.31 (PA30)
/SWDIO: J2.2, U1.32 (PA31)
/USB_D+: J5.3 (D+), U1.24 (PA25), U6.1, U6.6 (A)
/USB_D-: J5.2 (D-), U1.23 (PA24), U6.3, U6.4 (B)
/V_SENSE: R3.1, R9.2, U1.5 (PA04)
/~RESET: C19.1, J2.10, U1.26 (~RESET)
GND: C1.2, C2.2, C3.1, C4.2, C5.2, C6.2, C7.2, C9.2, C10.1, C11.1, C12.1, C13.1, C14.2, C15.1, C17.1, C18.2, C19.2, D5.2 (A), D8.2 (A), E1.2, E2.2, E3.2, E4.2, E5.2, E6.2, E7.2, J1.2, J2.3, J2.5, J2.9, J5.5 (GND), J6.1, J6.2, J6.4, J6.6, J6.7, J6.8, J7.1, J7.2, J7.4, J7.6, J7.7, J8.1, J8.2, J8.4, J8.6, J8.7, J8.8, J9.1, J9.2, J9.4, J9.6, J9.7, R3.2, R4.2, R5.1, R6.2, R7.2, R10.2, U1.10 (GND), U1.28 (GND), U2.2 (GND), U3.1 (GND), U3.12 (SENSE_A), U3.18 (GND), U3.19 (GND), U3.25 (SENSE_B), U3.36 (GND), U3.37 (SLUG), U4.2 (GND), U5.2 (GND), U6.2 (GND), U6.5 (GND), Y1.2, Y1.4
unnamed: C4.1, D6.3 (K), FB1.1, U5.1 (VIN), U5.3 (ON/~OFF~)
unnamed: C8.1, D1.2 (K), U3.30 (VBOOT)
unnamed: C14.1, U1.15 (PA14), Y1.1
unnamed: C15.2, U1.16 (PA15), Y1.3
unnamed: C16.1, U3.7 (VCP)
unnamed: C16.2, R17.1
unnamed: C17.2, J5.6 (Shield), R10.1
unnamed: D1.3 (common), R17.2
unnamed: D3.2 (BK), R16.1
unnamed: D3.3 (GK), R15.1
unnamed: D3.4 (RK), R12.1
unnamed: D4.2 (BK), R13.1
unnamed: D4.3 (GK), R14.1
unnamed: D4.4 (RK), R11.1
unnamed: D5.1 (K), FB1.2, J5.1 (VBUS)
unnamed: D8.1 (K), E1.1, FB2.2, J1.1
unnamed: E2.1, J3.1, U3.5 (OUT2_A)
unnamed: E3.1, J3.2, R6.1, U3.15 (OUT1_A)
unnamed: E4.1, J3.3, R6.3
unnamed: E5.1, J4.1, U3.32 (OUT2_B)
unnamed: E6.1, J4.2, R7.1, U3.22 (OUT1_B)
unnamed: E7.1, J4.3, R7.3
unnamed: R4.1, U3.9 (PROGCL_A)
unnamed: R5.2, U3.28 (PROGCL_B)
unnamed: R11.2, U1.19 (PA18)
unnamed: R12.2, U1.22 (PA23)
unnamed: R13.2, U1.17 (PA16)
unnamed: R14.2, U1.18 (PA17)
unnamed: R15.2, U1.21 (PA22)
unnamed: R16.2, U1.20 (PA19)

Notes on the sheet:
Pin3: Resistor limits current for short wires. 10W @ 48V = 0,2A => 240Ohm This resistor won't survive 48V short circuit! Power restistors cooled with GND plane.
Overcurrent Limit of approx. 1A No current sense resistor
USB and 48V power source are connected to create a ORed power schema. This enables to program the system without 48V present. The diodes prevent reverse output faults.
N/C pins used for better routing (see datasheet)
lower PCB
upper PCB

Board: 2 copper layers, 131.0 x 50.2 mm, 74 parts (9 on the bottom side), 48 nets.

## KiCad design pcb/sensor/sensor.kicad_pcb

Parts:
C1, C2, C3: 4p7; C_0805_2012Metric; Partnumber C0805C479D5GACTU
C5, C6, C7, C9, C10, C11, C13: 10n; C_0805_2012Metric; Partnumber CL21B103KBANNNC
C14, C15: 22p; C_0805_2012Metric; Partnumber C0805C220K5GACTU
C16, C17, C18: 4µ7; C_0805_2012Metric; Partnumber CL21A475KOFNNNE
C19: 47u; CP_EIA-6032-28_Kemet-C; Partnumber TAJC476K020R
C20, C21, C22, C23, C24, C25, C26, C27, C28, C29, C30, C31, C32, C33, C34: 100n; C_0805_2012Metric; Partnumber CL21B104MBCNNNC
D1: 5V; D_SMB; Partnumber SMBJ5.0A-TR
FB1, FB2: BLM31KN471SN1L; L_1206_3216Metric; Partnumber BLM31KN471SN1L
FID1, FID2: Fiducial; Fiducial_0.5mm_Mask1mm
J1: USB; JST_PH_B5B-PH-K_1x05_P2.00mm_Vertical; Partnumber B05B-PASK
J2: SWD; PinHeader_2x05_P1.27mm_Vertical; Partnumber HPH2-A-10-UA
L1, L2: 100mH; L_Axial_L12.0mm_D5.0mm_P15.24mm_Horizontal_Fastron_MISC; Partnumber B82144A2107J000
L3: 100mH; L_Axial_L12.0mm_D5.0mm_P5.08mm_Vertical_Fastron_MISC; Partnumber B82144A2107J000
N1: CU-1952; Partnumber CU-1952
NT1: Net-Tie_2; NetTie-2_SMD_Pad2.0mm
R1, R2, R3: 47k; R_0805_2012Metric; Partnumber RMCF0805FT47K0
R6, R7, R8, R9: 1M; R_0805_2012Metric; Partnumber RMCF0805FT1M00
R13, R14, R15: 787; R_0805_2012Metric; Partnumber RMCF0805FT787R
R17, R18, R19: 787k; R_0805_2012Metric; Partnumber RMCF0805FT787K
R21, R22, R23: 15k8; R_0805_2012Metric; Partnumber RMCF0805FT15K8
R25, R26, R27: 200k; Potentiometer_Bourns_TC33X_Vertical; Partnumber TC33X-2-204E
R29, R30, R31, R32, R33, R34, R37, R38, R39: 10k; R_0805_2012Metric; Partnumber RMCF0805FT10K0
R40: 1k; R_0805_2012Metric; Partnumber RMCF0805FT1K00
U1, U2: TLV9064; SOIC-14_3.9x8.7mm_P1.27mm; Partnumber TLV9064IDR
U3: ATSAMD21E; TQFP-32_7x7mm_P0.8mm; Partnumber ATSAMD21E17A-AU
U4: MCP1700-3302E; SOT-23; Partnumber MCP1700T-3302E/TT
U5: SN65220; SOT-23-6; Partnumber SN65220DBVRG4
U6: ADR130; TSOT-23-6; Partnumber ADR130AUJZ-REEL7
U7, U8, U9: DRV5053VA; SOT-23; Partnumber DRV5053VAQDBZR
Y1: 16MHz; Crystal_SMD_SeikoEpson_TSX3225-4Pin_3.2x2.5mm; Partnumber TSX-3225 16.0000MF10U-B0

Connections:
+3.3VA: C17.1, C21.1, C23.1, C27.2, C28.2, C29.2, C30.2, FB1.1, U1.4 (V+), U2.4 (V+), U3.9 (VDDANA), U6.3 (VIN), U7.1 (VCC), U8.1 (VCC), U9.1 (VCC)
+3V3: C18.1, C19.1, C22.2, FB1.2, J2.1, R40.2, U3.30 (VDDIN), U4.2 (VO)
+5V: C26.2, D1.1 (K), FB2.1, J1.1
/MAG_A: C31.2, R37.1, U3.11 (PA08)
/MAG_B: C32.2, R38.1, U3.12 (PA09)
/MAG_C: C33.2, R39.1, U3.13 (PA10)
/SENSE_A: R17.2, R29.1, U1.7, U3.6 (PA05)
/SENSE_B: R18.2, R31.1, U1.14, U3.5 (PA04)
/SENSE_C: R19.2, R33.1, U2.7, U3.7 (PA06)
/SWCLK: J2.4, R40.1, U3.31 (PA30)
/SWDIO: J2.2, U3.32 (PA31)
/USB_D+: J1.3, U3.24 (PA25), U5.1, U5.6 (A)
/USB_D-: J1.2, U3.23 (PA24), U5.3, U5.4 (B)
/V_GND: C5.1, C6.1, C7.1, C20.1, C24.1, C25.1, C34.1, L1.1, L2.1, L3.1, R21.2, R22.2, R23.2, R30.2, R32.2, R34.2, U1.3 (+), U1.10 (+), U2.3 (+), U3.3 (PA02), U6.4 (VOUT), U6.5 (SET)
/~RESET: J2.10, U3.26 (~RESET)
GND: C13.2, C14.1, C15.1, C16.2, C18.2, C19.2, C22.1, C26.1, C27.1, D1.2 (A), J1.4, J2.3, J2.5, J2.9, NT1.2, R9.1, U3.10 (GND), U3.28 (GND), U4.1 (GND), U5.2 (GND), U5.5 (GND), Y1.2, Y1.4
GNDA: C17.2, C20.2, C21.2, C23.2, C24.2, C25.2, C28.1, C29.1, C30.1, C31.1, C32.1, C33.1, C34.2, NT1.1, U1.11 (V-), U2.11 (V-), U6.2 (GND), U7.3 (GND), U8.3 (GND), U9.3 (GND)
unnamed: C1.1, R8.2, R13.2, U1.1
unnamed: C1.2, R1.1, R8.1, U1.2 (-)
unnamed: C2.1, R6.2, R14.2, U1.8
unnamed: C2.2, R2.1, R6.1, U1.9 (-)
unnamed: C3.1, R7.2, R15.2, U2.1
unnamed: C3.2, R3.1, R7.1, U2.2 (-)
unnamed: C5.2, C9.2, R13.1, R17.1
unnamed: C9.1, R21.1, U1.5 (+)
unnamed: C10.1, R22.1, U1.12 (+)
unnamed: C6.2, C10.2, R14.1, R18.1
unnamed: C11.1, R23.1, U2.5 (+)
unnamed: C7.2, C11.2, R15.1, R19.1
unnamed: C13.1, J1.5, R9.2
unnamed: C14.2, U3.15 (PA14), Y1.1
unnamed: C15.2, U3.16 (PA15), Y1.3
unnamed: C16.1, FB2.2, U4.3 (VI)
unnamed: L1.2, R1.2
unnamed: L2.2, R2.2
unnamed: L3.2, R3.2
unnamed: R25.1, R29.2
unnamed: R25.2, R30.1, U1.6 (-)
unnamed: R26.1, R31.2
unnamed: R26.2, R32.1, U1.13 (-)
unnamed: R27.1, R33.2
unnamed: R27.2, R34.1, U2.6 (-)
unnamed: R37.2, U7.2 (VOUT)
unnamed: R38.2, U8.2 (VOUT)
unnamed: R39.2, U9.2 (VOUT)

Notes on the sheet:
Virtual ground at 0.5V
LR Low-Pass C dampens resonants gain -21
N/C pins used for better routing (see datasheet)
Magnetic sensors f_max = 160Hz
Sallen key bandpass, hpf eliminates offset and 50Hz lpf is anti aliasing filter configurable gain 1-20

Board: 4 copper layers, 67.3 x 38.1 mm, 80 parts (0 on the bottom side), 45 nets.

## Code that names these connections

File firmware/generator/driver_init.c (part):

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	adc_async_register_channel_buffer(&ADC_0, 0, ADC_0_buffer, ADC_0_BUFFER_SIZE);

	// Disable digital pin circuitry
	gpio_set_pin_direction(V_SENSE, GPIO_DIRECTION_OFF);

	gpio_set_pin_function(V_SENSE, PINMUX_PA04B_ADC_AIN4);

	// Disable digital pin circuitry
	gpio_set_pin_direction(R_TEMP, GPIO_DIRECTION_OFF);

	gpio_set_pin_function(R_TEMP, PINMUX_PA05B_ADC_AIN5);
}

void FLASH_INSTANCE_CLOCK_init(void)
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{
	init_mcu();

	// GPIO on PA00

	gpio_set_pin_level(EN_B,
	                   // <y> Initial level
	                   // <id> pad_initial_level
	                   // <false"> Low
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	                   false);

	// Set pin direction to output
	gpio_set_pin_direction(EN_B, GPIO_DIRECTION_OUT);

	gpio_set_pin_function(EN_B, GPIO_PIN_FUNCTION_OFF);

	// GPIO on PA01

	// Set pin direction to input
	gpio_set_pin_direction(ERROR_B, GPIO_DIRECTION_IN);

	gpio_set_pin_pull_mode(ERROR_B,
	                       // <y> Pull configuration
	                       // <id> pad_pull_config
	                       // <GPIO_PULL_OFF"> Off
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	                       // <GPIO_PULL_DOWN"> Pull-down
	                       GPIO_PULL_OFF);

	gpio_set_pin_function(ERROR_B, GPIO_PIN_FUNCTION_OFF);

	// GPIO on PA02

	gpio_set_pin_level(IN1_B,
	                   // <y> Initial level
	                   // <id> pad_initial_level
	                   // <false"> Low
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	                   false);

	// Set pin direction to output
	gpio_set_pin_direction(IN1_B, GPIO_DIRECTION_OUT);

	gpio_set_pin_function(IN1_B, GPIO_PIN_FUNCTION_OFF);

	// GPIO on PA03

	gpio_set_pin_level(IN2_B,
	                   // <y> Initial level
	                   // <id> pad_initial_level
	                   // <false"> Low
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	                   false);

	// Set pin direction to output
	gpio_set_pin_direction(IN2_B, GPIO_DIRECTION_OUT);

	gpio_set_pin_function(IN2_B, GPIO_PIN_FUNCTION_OFF);

	// GPIO on PA06

	gpio_set_pin_level(IN1_A,
	                   // <y> Initial level
	                   // <id> pad_initial_level
	                   // <false"> Low
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	                   false);

	// Set pin direction to output
	gpio_set_pin_direction(IN1_A, GPIO_DIRECTION_OUT);

	gpio_set_pin_function(IN1_A, GPIO_PIN_FUNCTION_OFF);

	// GPIO on PA07

	gpio_set_pin_level(IN2_A,
	                   // <y> Initial level
	                   // <id> pad_initial_level
	                   // <false"> Low
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	                   false);

	// Set pin direction to output
	gpio_set_pin_direction(IN2_A, GPIO_DIRECTION_OUT);

	gpio_set_pin_function(IN2_A, GPIO_PIN_FUNCTION_OFF);

	// GPIO on PA08

	gpio_set_pin_level(EN_A,
	                   // <y> Initial level
	                   // <id> pad_initial_level
	                   // <false"> Low
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	                   false);

	// Set pin direction to output
	gpio_set_pin_direction(EN_A, GPIO_DIRECTION_OUT);

	gpio_set_pin_function(EN_A, GPIO_PIN_FUNCTION_OFF);

	// GPIO on PA09

	// Set pin direction to input
	gpio_set_pin_direction(ERROR_A, GPIO_DIRECTION_IN);

	gpio_set_pin_pull_mode(ERROR_A,
	                       // <y> Pull configuration
	                       // <id> pad_pull_config
	                       // <GPIO_PULL_OFF"> Off
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	                       // <GPIO_PULL_DOWN"> Pull-down
	                       GPIO_PULL_OFF);

	gpio_set_pin_function(ERROR_A, GPIO_PIN_FUNCTION_OFF);

	// GPIO on PA16

	gpio_set_pin_level(LED2_B,
	                   // <y> Initial level
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
	gpio_set_pin_function(LED2_B, GPIO_PIN_FUNCTION_OFF);

	// GPIO on PA17

	gpio_set_pin_level(LED2_G,
	                   // <y> Initial level
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
	gpio_set_pin_function(LED2_G, GPIO_PIN_FUNCTION_OFF);

	// GPIO on PA18

	gpio_set_pin_level(LED2_R,
	                   // <y> Initial level
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
	gpio_set_pin_function(LED2_R, GPIO_PIN_FUNCTION_OFF);

	// GPIO on PA19

	gpio_set_pin_level(LED1_B,
	                   // <y> Initial level
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
	gpio_set_pin_function(LED1_B, GPIO_PIN_FUNCTION_OFF);

	// GPIO on PA22

	gpio_set_pin_level(LED1_G,
	                   // <y> Initial level
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
	gpio_set_pin_function(LED1_G, GPIO_PIN_FUNCTION_OFF);

	// GPIO on PA23

	gpio_set_pin_level(LED1_R,
	                   // <y> Initial level
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
File firmware/sensor/atmel_start_pins.h:

/*
 * Code generated from Atmel Start.
 *
 * This file will be overwritten when reconfiguring your Atmel Start project.
 * Please copy examples or other code you want to keep to a separate file
 * to avoid losing it when reconfiguring.
 */
#ifndef ATMEL_START_PINS_H_INCLUDED
#define ATMEL_START_PINS_H_INCLUDED

#include <hal_gpio.h>

// SAMD21 has 8 pin functions

#define GPIO_PIN_FUNCTION_A 0
#define GPIO_PIN_FUNCTION_B 1
#define GPIO_PIN_FUNCTION_C 2
#define GPIO_PIN_FUNCTION_D 3
#define GPIO_PIN_FUNCTION_E 4
#define GPIO_PIN_FUNCTION_F 5
#define GPIO_PIN_FUNCTION_G 6
#define GPIO_PIN_FUNCTION_H 7

#define V_GND GPIO(GPIO_PORTA, 2)
#define SENSA_B GPIO(GPIO_PORTA, 4)
#define SENSE_A GPIO(GPIO_PORTA, 5)
#define SENSE_C GPIO(GPIO_PORTA, 6)
#define MAG_A GPIO(GPIO_PORTA, 8)
#define MAG_B GPIO(GPIO_PORTA, 9)
#define MAG_C GPIO(GPIO_PORTA, 10)
#define PA24 GPIO(GPIO_PORTA, 24)
#define PA25 GPIO(GPIO_PORTA, 25)

#endif // ATMEL_START_PINS_H_INCLUDED

## Commit log

2019-05-17 Initial perimeter wire firmware and driver
2019-05-20 Add pcb
2019-05-28 Sensor pcb complete
2019-05-28 Fix lib in generator schematic
2019-05-28 TEMP Add Readme
2019-05-28 TEMP Sensor spice simulation kicad simulation does not work with opamp multiple ltspice simulations pw_original (RobotShop version) pw_my (My version) pw_ti (My version with sally key bandpass) <= Us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
2019-05-28 TEMP Line follower
2019-05-28 TEMP Firmware experiments sensor_simple is the original atmega version sensor_import is SimpleAudioFrequencyMeter arduino example imported into atmel studio (not working) GccApplication is a atmel st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
    arduino <= use this is a arduino sketch with usefull classes (FixedPrecision, IIR filter)
    USE ARDINO, DELETE the rest
2019-06-03 Replace ferrite beads with smd types
2019-09-01 Use GNDA for ground layer Cleanup silk and fab
2019-09-01 Add generator pcb
2019-09-02 Release preparation
2019-11-20 Sensor spice simulation kicad simulation does not work with opamp multiple ltspice simulations pw_original (RobotShop version) pw_my (My version) pw_ti (My version with sally key bandpass) <= Use thi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
2019-11-20 Add Readme
2019-11-20 Add generator firmware (initial) Missing features - LEDs
2019-11-20 Implement reading the temperature
2019-11-20 Add generator driver
2019-11-20 Cleanup sensor driver, add preliminary sensor firmware
2019-11-20 Change sensor device to samd11 Integrate correlation filter
2019-11-20 Fix resistor value (787->787k)
2019-11-20 Generator with divider configuration
2019-11-20 sensor driver: Fix timing
2019-11-20 generator: Initial configuration with enabled ch1, div 5 (till nv save is implemented)
2019-11-20 Calculate timer frequency
2019-11-20 Sensor firmware (no XOSC32, because it's not oscillating)
2019-11-20 On demand usb connect
2019-11-20 Change generator device to SAMD11 Add leds
2019-11-20 Implement codes and signed magnitude
2019-11-20 Fix firmware include path
2019-11-20 Implement differential, repeat Cleanup
2019-11-20 Line follower
2020-01-18 sensor driver: debug log: print each char
2020-01-18 sensor firmware: use external oscillator
2020-01-18 sensor driver: Check control register
2020-01-18 sensor firmware: react on register change selectively
2020-01-22 Replace mcu, add hall sensors, replace tht components
2020-01-22 sensor R2
2020-01-22 Change op type to SOIC
2020-01-22 Add housing / fix partnumbers
2020-01-22 Prepare next pcb
2020-01-22 generator: pcb for modulbox
2020-01-22 Place and route smaller pcb
2020-01-22 Replace 4u7 cap on V_GND with 100n (voltage reference can't drive more than 1u) Refs C19 C20 swapped
2020-01-22 Add device packs and cmake for arm
2020-01-22 Update firmware for pcb r2
2020-01-22 generator: Update parnumbers (for r2)
2020-01-22 gernerator pcb r2 - place references - adjust mask clearance
2020-02-26 generator firmware: implement temperature off
2020-02-26 Debug documentation
2020-02-26 generator pcb: replace SMBJ48CA with SMBJ48A
2020-02-26 Replace ATSAMD21E17A with ATSAMD21E17D
2020-02-26 generator firmware: set default mode and code
2020-02-26 generator firmware: fix build
2020-02-26 cmake: Implement programming with cmake
2020-02-26 generator driver: implement voltage and temperature
2020-02-26 generator firmware: update for pcb r2
2020-03-03 bootloader: Restructure, create package / cmake
2020-03-03 bootloader: add timeout, fix app detection
2020-03-03 Import bootloader from https://github.com/arduino/ArduinoCore-samd (zero bootloader) Modified to support SAMD21E17D
2020-03-03 cmake: create bin file, drop eeprom
2020-03-03 bootloader: rename project
2020-03-03 bootloader: remove jtag support
2020-03-03 sensor firmware: Make firmware bootloader compatible
2020-03-11 firmware: program and test script
2020-04-03 generator: add code metrics
2020-04-03 remove submodules
2020-04-03 firmware: Synchronize generation and sampling rate
2020-04-03 sensor: implement direct buffer access
2020-04-03 implement reset to bootloader
2020-04-03 sensor: use 12-bit and diffential mode adc
2020-04-03 sensor firmware: enable inputscan
2020-04-03 sensor firmware: Run cpu at 48MHz
2020-04-03 sensor: read all channels at once, add sync mode
2020-04-03 Add numieric simulation
2020-04-03 generator firmware: Implement nv storage
2020-04-06 sensor firmware: add error handler
2020-04-06 sensor firmware: add timer for adc reset
2020-04-06 sensor: add filter and measurement count, speed up
2020-04-06 sensor firmware: fix usb_serial
2020-04-06 sensor driver: improve output, disable on start
2020-04-06 sensor driver: normalize output to 0..1
2020-04-06 Change include dirs to project names
2020-04-14 Add changelogs
2020-04-14 0.0.1
2020-04-18 add debian/rules.em to mcu packages
2020-04-20 firmware: update dependencies
2020-04-21 generator driver: fix dependencies
2020-05-10 sensor driver: Add information about code weight to console
2020-05-10 prod: add doc and script for testing
2020-05-10 sensor driver: add orientation parameter
2020-05-10 Update changelogs
2020-05-10 0.0.2
2020-06-25 generator fw: Add bootloader configuration
2020-06-25 prod: add sensor_test.launch
2020-06-25 prod: Update programming and testing documentation
2020-06-25 driver: log info about orientation
2020-06-30 0.0.3
2020-11-05 Improve firmware programming and testing
2024-01-02 Add license information
